<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Test13_USART_Receive_Send.ewp</path>
  </project>
  <batchBuild/>
</workspace>


