# IAR project Test13_USART_Receive_Send.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S105C6 STM8S105C6
  General.GenCodeModel: 0
  General.GenDataModel: 2
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: Gizwits; Utils
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: Test13_USART_Receive_Send.hex
  ILINK.IlinkOutputFile: Test13_USART_Receive_Send.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenDataModel: 1
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    ./: main.c
  group Gizwits
    Gizwits/: gizwits_product.c gizwits_protocol.c
  group Utils
    Utils/: common.c dataPointTools.c ringbuffer.c
